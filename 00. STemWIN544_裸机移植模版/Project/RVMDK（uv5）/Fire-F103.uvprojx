# Keil uVision project Fire-F103.uvprojx, settings and files
target Fire-F103 (5060960::V5.06 update 7 (build 960)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Fire-F103 +hex
  c flags: Optim=2 oTime=1 OneElfS=1
  c define: STM32F10X_HD, USE_STDPERIPH_DRIVER
  c include: ..\..\Libraries\CMSIS;..\..\User;..\..\Libraries\FWlib\inc;..\..\User\usart;..\..\User\sram;..\..\User\led;..\..\User\flash;..\..\User\lcd;..\..\STemWin\Config;..\..\STemWin\inc;..\..\STemWin_Task;..\..\User\FATFS;..\..\User\FATFS\option
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group STARTUP
    ../../Libraries/CMSIS/startup/: startup_stm32f10x_hd.s
  group CMSIS
    ../../Libraries/CMSIS/: core_cm3.c core_cm3.h stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group FWLB
    ../../Libraries/FWlib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group USER
    ../../User/: main.c stm32f10x_it.c
    ../../User/led/: bsp_led.c
    ../../User/usart/: bsp_usart.c
    ../../User/lcd/: bsp_ili9341_lcd.c bsp_xpt2046_lcd.c
    ../../User/SysTick/: bsp_SysTick.c
    ../../User/sram/: bsp_fsmc_sram.c
    ../../User/Key/: bsp_key.c
    ../../User/TPad/: bsp_tpad.c
    ../../User/Beep/: bsp_beep.c
    ../../User/sdio/: bsp_sdio_sdcard.c
    ../../User/font/: fonts.c
  group STemWIN
    ../../STemWin/Config/: GUIConf.c GUIConf.h LCDConf_FlexColor.c GUI_X_Touch_Analog.c
    ../../STemWin/OS/: GUI_X.c
    ../../STemWin/Lib/: STemWin_CM3_wc16_ARGB.a
  group STemWIN/Task
    ../../STemWin_Task/: MainTask.c Touch_calibration.c
  group FATFS
    ../../User/FATFS/: diskio.c ff.c
    ../../User/FATFS/option/: cc936.c
  group DOC
    ../../Doc/: readme.txt
